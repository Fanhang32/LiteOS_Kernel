# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO STM32F4 LOS_STM32F407VG STM32F407xx
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m4;..\..\example\include;..\..\platform\STM32F407_DISCO;..\..\STM32FXXX\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\STM32FXXX\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\STM32FXXX\stm32f4-discovery\Inc;..\..\STM32FXXX\Drivers\BSP\STM32F4-Discovery;..\..\STM32FXXX\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\platform\STM32F407_DISCO\STM32F407-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32f4-discovery
    ../../platform/STM32F407_DISCO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_cmsis_main.c los_inspect_entry.c
  group startup
    ../../platform/STM32F429I_DISCO/: los_startup_keil.s
    ../../STM32FXXX/stm32f4-discovery/: startup_stm32f407xx.s
  group user
    ../../user/: main.c
  group stm32fxxx
    ../../STM32FXXX/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
    ../../STM32FXXX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
    ../../STM32FXXX/stm32f4-discovery/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
software components: CMSIS:CORE 5.0.1
